# Keil uVision project HoneyGUI.uvprojx, settings and files
target gui_sim (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app
  c flags: Optim=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: DRV_LCD_WIDTH=480 DRV_PIXEL_BITS=16 ENABLE_RTK_GUI_CONSOLE DRV_LCD_HEIGHT=480 ENABLE_HONEYGUI
  c misc: --diag_suppress=1
  c include: .;.;..\..\realgui\example\root_image;gui_port;..\..\realgui;..\..\realgui\3rd\cgltf;..\..\realgui\3rd\cJSON;..\..\realgui\3rd\ezXML;..\..\realgui\3rd\gifdec;..\..\realgui\3rd\letter_shell;..\..\realgui\3rd\nanosvg\src;..\..\realgui\3rd\nanovg;..\..\realgui\3rd\nanovg\agge;..\..\realgui\3rd\nanovg\base;..\..\realgui\3rd\nanovg\agge;..\..\realgui\3rd\nanovg\vglite;..\..\realgui\3rd\stb;..\..\realgui\3rd\tinyobj;..\..\realgui\3rd\tjpgd;..\..\realgui\3rd\h264bsd;..\..\realgui\3rd\h264bsd\src;..\..\realgui\3rd\h264bsd\port;..\..\realgui\3rd\h264bsd\inc;..\..\realgui\3rd\minimp3;..\..\realgui\core;..\..\realgui\dc;..\..\realgui\engine;..\..\realgui\engine\font;..\..\realgui\engine\sw;..\..\realgui\engine\sw\idu;..\..\realgui\engine\sw\rle;..\..\realgui\input;..\..\realgui\misc;..\..\realgui\misc\tlsf;..\..\realgui\SaaA;..\..\realgui\server;..\..\realgui\widget;..\..\realgui\widget\gui_canvas;..\..\realgui\widget\gui_glass;..\..\realgui\widget\gui_gray;..\..\realgui\widget\gui_img;..\..\realgui\widget\gui_list;..\..\realgui\widget\gui_lite_geometry;..\..\realgui\widget\gui_menu_cellular;..\..\realgui\widget\gui_obj;..\..\realgui\widget\gui_qbcode;..\..\realgui\widget\gui_soccer;..\..\realgui\widget\gui_text;..\..\realgui\widget\gui_video;..\..\realgui\widget\gui_view;..\..\realgui\widget\gui_win;..\..\example\widget\glass_effect;..\..\example\widget\glass_effect\root_image;..\..\example\widget\image
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  group application
    ./: main.c
  group gui_port
    gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_os.c
  group realgui/3rd
    ../../realgui/3rd/cJSON/: cJSON.c
    ../../realgui/3rd/ezXML/: ezxml.c
    ../../realgui/3rd/gifdec/: gifdec.c
    ../../realgui/3rd/letter_shell/: shell.c shell_companion.c shell_ext.c shell_fs.c shell_port.c
    ../../realgui/3rd/nanovg/base/: nanovg_port.c nanovg.c
    ../../realgui/3rd/nanovg/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp nanovg_agge.cpp nanovg_vertex.cpp
    ../../realgui/3rd/stb/: stb_image.cpp
    ../../realgui/3rd/tjpgd/: tjpgd.c
  group realgui/3rd/h264bsd
    ../../realgui/3rd/h264bsd/src/: YUV2RGB.c gui_h264bsd.c h264bsdTest.c h264bsd_byte_stream.c h264bsd_cavlc.c h264bsd_conceal.c h264bsd_deblocking.c h264bsd_decoder.c h264bsd_dpb.c h264bsd_image.c h264bsd_inter_prediction.c h264bsd_intra_prediction.c h264bsd_macroblock_layer.c h264bsd_nal_unit.c h264bsd_neighbour.c h264bsd_pic_order_cnt.c h264bsd_pic_param_set.c h264bsd_reconstruct.c h264bsd_sei.c h264bsd_seq_param_set.c h264bsd_slice_data.c h264bsd_slice_group_map.c h264bsd_slice_header.c h264bsd_storage.c h264bsd_stream.c h264bsd_transform.c h264bsd_util.c h264bsd_vlc.c h264bsd_vui.c
    ../../realgui/3rd/h264bsd/port/: h264bsd_port.c
  group realgui/dc
    ../../realgui/dc/: gui_fb.c
  group realgui/engine
    ../../realgui/engine/: acc_api.c draw_font.c draw_img.c engine_gray.c gui_matrix.c gui_post_process.c
    ../../realgui/engine/font/: font_custom.c font_mem.c font_mem_img.c font_mem_matrix.c font_rendering_utils.c font_stb.c font_ttf.c
    ../../realgui/engine/sw/: a8_2_a8.c a8_2_rgb565.c acc_sw.c acc_sw_arm2d_blur.c acc_sw_raster.c argb8565_2_rgb565.c rgb565_2_rgb565.c
    ../../realgui/engine/sw/idu/: acc_sw_idu.c
    ../../realgui/engine/sw/rle/: acc_sw_rle.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
  group realgui/input
    ../../realgui/input/: kb_algo.c tp_algo.c wheel_algo.c
  group realgui/misc
    ../../realgui/misc/tlsf/: tlsf.c
  group realgui/server
    ../../realgui/server/: gui_api_acc.c gui_api_color.c gui_api_dc.c gui_api_fs.c gui_api_ftl.c gui_api_indev.c gui_api_os.c gui_components_init.c gui_message.c gui_pm.c gui_server.c
  group realgui/widget
    ../../realgui/widget/gui_canvas/: gui_canvas.c gui_canvas_arc.c gui_canvas_img.c gui_canvas_rect.c gui_canvas_round_rect.c
    ../../realgui/widget/gui_glass/: gui_glass.c
    ../../realgui/widget/gui_gray/: gui_gray.c
    ../../realgui/widget/gui_img/: gui_img.c gui_img_api.c
    ../../realgui/widget/gui_list/: gui_list.c gui_list_rotate_curl.c gui_list_rotate_helix.c
    ../../realgui/widget/gui_lite_geometry/: gui_lite_geometry_arc.c gui_lite_geometry_circle.c gui_lite_geometry_round_rect.c lite_geometry.c lite_geometry_math.c
    ../../realgui/widget/gui_menu_cellular/: gui_menu_cellular.c
    ../../realgui/widget/gui_obj/: gui_obj.c gui_obj_event.c gui_obj_suppress.c gui_obj_timer.c gui_obj_tree.c
    ../../realgui/widget/gui_qbcode/: gui_barcode_gen.c gui_qbcode.c gui_qrcode_gen.c
    ../../realgui/widget/gui_soccer/: gui_soccer.c
    ../../realgui/widget/gui_text/: gui_scroll_text.c gui_text.c
    ../../realgui/widget/gui_video/: gui_video.c
    ../../realgui/widget/gui_view/: gui_view.c gui_view_animate.c gui_view_blur.c gui_view_cube.c gui_view_descriptor.c gui_view_reduction.c gui_view_rotate.c gui_view_translation.c
    ../../realgui/widget/gui_win/: gui_win.c
  group realgui/demo
    ../../example/widget/image/: example_gui_img.c
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Device:Startup 1.1.0
