# Keil uVision project HoneyGUI.uvprojx, settings and files
target gui_sim (6220000::V6.22::..\..\AC\622)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x00000000,0x00080000) IROM(0x10000000,0x00200000) XRAM(0x01000000,0x00100000) XRAM2(0x20000000,0x00020000) XRAM3(0x20020000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app
  c flags: Optim=2 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: GUI_KEIL_SIM ENABLE_HONEYGUI
  c include: .;.;.;..\..\realgui\example\root_image;gui_port;platform;..\..\realgui;..\..\realgui\3rd\cJSON;..\..\realgui\3rd\ezXML;..\..\realgui\3rd\gifdec;..\..\realgui\3rd\nanosvg\src;..\..\realgui\3rd\nanovg;..\..\realgui\3rd\nanovg\agge;..\..\realgui\3rd\nanovg\base;..\..\realgui\3rd\nanovg\agge;..\..\realgui\3rd\nanovg\vglite;..\..\realgui\3rd\stb;..\..\realgui\3rd\tinyobj;..\..\realgui\3rd\tjpgd;..\..\realgui\3rd\h264bsd;..\..\realgui\3rd\h264bsd\inc;..\..\realgui\3rd\minimp3;..\..\realgui\core;..\..\realgui\dc;..\..\realgui\engine;..\..\realgui\engine\sw;..\..\realgui\input;..\..\realgui\misc;..\..\realgui\misc\tlsf;..\..\realgui\SaaA;..\..\realgui\server;..\..\realgui\widget;..\..\realgui\widget\gui_3d;..\..\realgui\widget\gui_canvas;..\..\realgui\widget\gui_gray;..\..\realgui\widget\gui_img;..\..\realgui\widget\gui_list;..\..\realgui\widget\gui_menu_cellular;..\..\realgui\widget\gui_obj;..\..\realgui\widget\gui_qbcode;..\..\realgui\widget\gui_soccer;..\..\realgui\widget\gui_text;..\..\realgui\widget\gui_video;..\..\realgui\widget\gui_view;..\..\realgui\widget\gui_win
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x1000000 size 0x100000
  memory RVCT7: RAM 0x20000000 size 0x20000
  memory RVCT8: RAM 0x20020000 size 0x20000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x80000
  scatter file: .\fvp_sse300_mps3_s.sct
  group menuconfig
    ../../win32_sim/: menu_config.h
  group application
    ./: main.c
  group gui_port
    gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_os.c
    platform/: GLCD_Fonts.c GLCD_V2M-MPS3_AN547.c Touch_V2M-MPS3.c platform.c
  group realgui/3rd
    ../../realgui/3rd/cJSON/: cJSON.c
    ../../realgui/3rd/ezXML/: ezxml.c
    ../../realgui/3rd/gifdec/: gifdec.c
    ../../realgui/3rd/nanovg/base/: nanovg.c
    ../../realgui/3rd/nanovg/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp nanovg_agge.cpp nanovg_vertex.cpp
    ../../realgui/3rd/stb/: stb_image.cpp
    ../../realgui/3rd/tjpgd/: tjpgd.c
  group realgui/3rd/h264bsd
    ../../realgui/3rd/h264bsd/src/: YUV2RGB.c gui_h264bsd.c h264bsdTest.c h264bsd_byte_stream.c h264bsd_cavlc.c h264bsd_conceal.c h264bsd_deblocking.c h264bsd_decoder.c h264bsd_dpb.c h264bsd_image.c h264bsd_inter_prediction.c h264bsd_intra_prediction.c h264bsd_macroblock_layer.c h264bsd_nal_unit.c h264bsd_neighbour.c h264bsd_pic_order_cnt.c h264bsd_pic_param_set.c h264bsd_reconstruct.c h264bsd_sei.c h264bsd_seq_param_set.c h264bsd_slice_data.c h264bsd_slice_group_map.c h264bsd_slice_header.c h264bsd_storage.c h264bsd_stream.c h264bsd_transform.c h264bsd_util.c h264bsd_vlc.c h264bsd_vui.c
  group realgui/dc
    ../../realgui/dc/: gui_fb.c
  group realgui/engine
    ../../realgui/engine/: acc_api.c draw_img.c gui_matrix.c draw_font.c font_mem.c font_mem_img.c font_mem_matrix.c font_rendering_utils.c font_stb.c font_ttf.c engine_gray.c gui_post_process.c
    ../../realgui/engine/sw/: acc_sw.c acc_sw_arm2d_blur.c acc_sw_blend.c acc_sw_bypass.c acc_sw_cover.c acc_sw_filter.c acc_sw_raster.c acc_sw_rle.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
  group realgui/input
    ../../realgui/input/: kb_algo.c tp_algo.c wheel_algo.c
  group realgui/misc
    ../../realgui/misc/tlsf/: tlsf.c
  group realgui/server
    ../../realgui/server/: gui_api_acc.c gui_api_color.c gui_api_dc.c gui_api_fs.c gui_api_ftl.c gui_api_indev.c gui_api_os.c gui_components_init.c gui_message.c gui_pm.c gui_server.c
  group realgui/widget
    ../../realgui/widget/gui_3d/: def_3d_common.c def_3d_rect.c def_3d_tria.c gui_3d.c gui_3d_rect.c gui_3d_tria.c
    ../../realgui/widget/gui_canvas/: gui_canvas.c gui_canvas_arc.c gui_canvas_img.c gui_canvas_rect.c gui_canvas_round_rect.c
    ../../realgui/widget/gui_gray/: gui_gray.c
    ../../realgui/widget/gui_img/: gui_img.c gui_img_api.c
    ../../realgui/widget/gui_list/: gui_list.c gui_list_rotate_curl.c gui_list_rotate_helix.c
    ../../realgui/widget/gui_menu_cellular/: gui_menu_cellular.c
    ../../realgui/widget/gui_obj/: gui_obj.c gui_obj_animate.c gui_obj_event.c gui_obj_suppress.c gui_obj_timer.c gui_obj_tree.c
    ../../realgui/widget/gui_qbcode/: gui_barcode_gen.c gui_qbcode.c gui_qrcode_gen.c
    ../../realgui/widget/gui_soccer/: gui_soccer.c
    ../../realgui/widget/gui_text/: gui_scroll_text.c gui_text.c
    ../../realgui/widget/gui_video/: gui_video.c
    ../../realgui/widget/gui_view/: gui_view.c gui_view_animate.c gui_view_blur.c gui_view_cube.c gui_view_descriptor.c gui_view_reduction.c gui_view_rotate.c gui_view_translation.c
    ../../realgui/widget/gui_win/: gui_win.c
software components: CMSIS:CORE 6.1.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.3.1, Compiler:Event Recorder 1.4.0, Compiler:I/O:STDOUT 1.2.0
