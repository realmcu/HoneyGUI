# Keil uVision project gui_engine.uvprojx, settings and files
target HoneyGUI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HoneyGUI (library)
  AfterMake: header_copy.bat
  c flags: Optim=3 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LV_KCONFIG_IGNORE ENABLE_HONEYGUI LV_LVGL_H_INCLUDE_SIMPLE LV_CONF_INCLUDE_SIMPLE LV_USE_DEMO_WIDGETS LV_USE_DEMO_BENCHMARK
  c misc: --fpu=FPv5-SP --gnu  --bss_threshold=0 --library_interface=aeabi_clib --no-multibyte-chars
  c include: .;.;..\realgui;..\realgui\3rd\ezXML;..\realgui\3rd\nanosvg\src;..\realgui\3rd\nanovg;..\realgui\3rd\nanovg\agge;..\realgui\3rd\nanovg\base;..\realgui\3rd\nanovg\agge;..\realgui\3rd\nanovg\vglite;..\realgui\3rd\stb;..\realgui\3rd\tjpgd;..\realgui\app;..\realgui\core;..\realgui\dc;..\realgui\engine;..\realgui\input;..\realgui\misc;..\realgui\misc\tlsf;..\realgui\SaaA;..\realgui\server;..\realgui\widget;..\lvgl;..\lvgl\src;..\lvgl\src\core;..\lvgl\src\draw;..\lvgl\src\extra;..\lvgl\src\font;..\lvgl\src\hal;..\lvgl\src\misc;..\lvgl\src\widgets;..\lvgl\src\draw\arm2d;..\lvgl\src\draw\sdl;..\lvgl\src\draw\stm32_dma2d;..\lvgl\src\draw\sw;..\lvgl\src\draw\swm341_dma2d;..\lvgl\src\draw\nxp\pxp;..\lvgl\src\draw\nxp\vglite;..\lvgl\src\draw\rtk\ppe;..\lvgl\src\draw\rtk\vglite;..\lvgl\src\extra\layouts;..\lvgl\src\extra\libs;..\lvgl\src\extra\others;..\lvgl\src\extra\themes;..\lvgl\src\extra\widgets;..\lvgl\src\extra\layouts\flex;..\lvgl\src\extra\layouts\grid;..\lvgl\src\extra\libs\bmp;..\lvgl\src\extra\libs\ffmpeg;..\lvgl\src\extra\libs\freetype;..\lvgl\src\extra\libs\fsdrv;..\lvgl\src\extra\libs\gif;..\lvgl\src\extra\libs\png;..\lvgl\src\extra\libs\qrcode;..\lvgl\src\extra\libs\rlottie;..\lvgl\src\extra\libs\sjpg;..\lvgl\src\extra\others\fragment;..\lvgl\src\extra\others\gridnav;..\lvgl\src\extra\others\ime;..\lvgl\src\extra\others\imgfont;..\lvgl\src\extra\others\monkey;..\lvgl\src\extra\others\msg;..\lvgl\src\extra\others\snapshot;..\lvgl\src\extra\themes\basic;..\lvgl\src\extra\themes\default;..\lvgl\src\extra\themes\mono;..\lvgl\src\extra\widgets\animimg;..\lvgl\src\extra\widgets\calendar;..\lvgl\src\extra\widgets\chart;..\lvgl\src\extra\widgets\colorwheel;..\lvgl\src\extra\widgets\imgbtn;..\lvgl\src\extra\widgets\keyboard;..\lvgl\src\extra\widgets\led;..\lvgl\src\extra\widgets\list;..\lvgl\src\extra\widgets\menu;..\lvgl\src\extra\widgets\meter;..\lvgl\src\extra\widgets\msgbox;..\lvgl\src\extra\widgets\span;..\lvgl\src\extra\widgets\spinbox;..\lvgl\src\extra\widgets\spinner;..\lvgl\src\extra\widgets\tabview;..\lvgl\src\extra\widgets\tileview;..\lvgl\src\extra\widgets\win;..\lvgl\examples;..\lvgl\examples\anim;..\lvgl\examples\event;..\lvgl\examples\get_started;..\lvgl\examples\layouts;..\lvgl\examples\libs;..\lvgl\examples\others;..\lvgl\examples\porting;..\lvgl\examples\scroll;..\lvgl\examples\styles;..\lvgl\examples\widgets;..\lvgl\examples\layouts\flex;..\lvgl\examples\layouts\grid;..\lvgl\examples\libs\bmp;..\lvgl\examples\libs\ffmpeg;..\lvgl\examples\libs\freetype;..\lvgl\examples\libs\gif;..\lvgl\examples\libs\png;..\lvgl\examples\libs\qrcode;..\lvgl\examples\libs\rlottie;..\lvgl\examples\libs\sjpg;..\lvgl\examples\others\fragment;..\lvgl\examples\others\gridnav;..\lvgl\examples\others\ime;..\lvgl\examples\others\imgfont;..\lvgl\examples\others\monkey;..\lvgl\examples\others\msg;..\lvgl\examples\others\snapshot;..\lvgl\demos;..\lvgl\demos\benchmark;..\lvgl\demos\keypad_encoder;..\lvgl\demos\music;..\lvgl\demos\stress;..\lvgl\demos\widgets;..\lvgl\demos\music\assets
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fvp_sse300_mps3_s.sct
  group menuconfig
    ../win32_sim/: menu_config.h
  group realgui/3rd
    ../realgui/3rd/nanovg/base/: nanovg.c
    ../realgui/3rd/nanovg/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp nanovg_agge.cpp nanovg_vertex.cpp
    ../realgui/3rd/tjpgd/: tjpgd.c
  group realgui/app
    ../realgui/app/: gui_app.c
  group realgui/dc
    ../realgui/dc/: gui_fb.c
  group realgui/engine
    ../realgui/engine/: draw_img.c gui_matrix.c draw_font.c font_mem.c font_mem_img.c font_mem_matrix.c font_stb.c acc_sw.c acc_sw_raster.c acc_init.c acc_sw_blend.c acc_sw_rle.c acc_sw_cover.c acc_sw_bypass.c acc_sw_filter.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
  group realgui/input
    ../realgui/input/: kb_algo.c tp_algo.c tp_algo_v2.c wheel_algo.c
  group realgui/misc
    ../realgui/misc/tlsf/: tlsf.c
  group realgui/server
    ../realgui/server/: gui_api.c gui_components_init.c gui_message.c gui_pm.c gui_server.c
  group realgui/widget
    ../realgui/widget/: gui_barcode_gen.c gui_button.c gui_canvas.c gui_canvas_arc.c gui_canvas_img.c gui_canvas_rect.c gui_canvas_round_rect.c gui_card.c gui_cardview.c gui_colorwheel.c gui_cube.c gui_curtain.c gui_curtainview.c gui_eq.c gui_fps.c gui_gallery.c gui_grid.c gui_image_array.c gui_img.c gui_img_live.c gui_img_scope.c gui_img_stb.c gui_menu_cellular.c gui_multi_level.c gui_obj.c gui_page.c gui_pagelist.c gui_pagelistview.c gui_perspective.c gui_progressbar.c gui_qbcode.c gui_qrcode_gen.c gui_return.c gui_scroll_text.c gui_seekbar.c gui_simple_img.c gui_slider.c gui_soccer.c gui_svg.c gui_switch.c gui_tab.c gui_tab_cube.c gui_tab_fade.c gui_tab_reduction.c gui_tab_reduction_fade.c gui_tab_rotate.c gui_tabview.c gui_text.c gui_turn_table.c gui_watch_gradient_spot.c gui_watchface_gradient.c gui_wave.c gui_wheel_list.c gui_widget_template.c gui_win.c
  group LVGL
    ../lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../lvgl/src/extra/: lv_extra.c
    ../lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp_blend.c lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_vglite_buf.c lv_vglite_utils.c
    ../lvgl/src/draw/rtk/ppe/: lv_draw_rtk_ppe.c lv_draw_rtk_ppe_blend.c lv_draw_rtk_ppe_buffer.c lv_draw_rtk_ppe_rect.c lv_draw_rtk_ppe_utils.c
    ../lvgl/src/draw/rtk/vglite/: lv_draw_rtk_vglite.c lv_draw_rtk_vglite_arc.c lv_draw_rtk_vglite_blend.c lv_draw_rtk_vglite_line.c lv_draw_rtk_vglite_rect.c lv_vglite_rtk_buf.c lv_vglite_rtk_utils.c
    ../lvgl/src/extra/layouts/flex/: lv_flex.c
    ../lvgl/src/extra/layouts/grid/: lv_grid.c
    ../lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../lvgl/src/extra/others/monkey/: lv_monkey.c
    ../lvgl/src/extra/others/msg/: lv_msg.c
    ../lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../lvgl/src/extra/themes/default/: lv_theme_default.c
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../lvgl/src/extra/widgets/chart/: lv_chart.c
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../lvgl/src/extra/widgets/led/: lv_led.c
    ../lvgl/src/extra/widgets/list/: lv_list.c
    ../lvgl/src/extra/widgets/menu/: lv_menu.c
    ../lvgl/src/extra/widgets/meter/: lv_meter.c
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../lvgl/src/extra/widgets/span/: lv_span.c
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../lvgl/src/extra/widgets/win/: lv_win.c
    ../lvgl/examples/anim/: lv_example_anim_1.c lv_example_anim_2.c lv_example_anim_3.c lv_example_anim_timeline_1.c
    ../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
    ../lvgl/examples/event/: lv_example_event_1.c lv_example_event_2.c lv_example_event_3.c lv_example_event_4.c
    ../lvgl/examples/get_started/: lv_example_get_started_1.c lv_example_get_started_2.c lv_example_get_started_3.c
    ../lvgl/examples/porting/: lv_port_disp_template.c lv_port_fs_template.c lv_port_indev_template.c
    ../lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c
    ../lvgl/examples/styles/: lv_example_style_1.c lv_example_style_10.c lv_example_style_11.c lv_example_style_12.c lv_example_style_13.c lv_example_style_14.c lv_example_style_15.c lv_example_style_2.c lv_example_style_3.c lv_example_style_4.c lv_example_style_5.c lv_example_style_6.c lv_example_style_7.c lv_example_style_8.c lv_example_style_9.c
    ../lvgl/examples/assets/emoji/: img_emoji_F617.c
    ../lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c
    ../lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c
    ../lvgl/examples/libs/bmp/: lv_example_bmp_1.c
    ../lvgl/examples/libs/ffmpeg/: lv_example_ffmpeg_1.c lv_example_ffmpeg_2.c
    ../lvgl/examples/libs/freetype/: lv_example_freetype_1.c
    ../lvgl/examples/libs/gif/: img_bulb_gif.c lv_example_gif_1.c
    ../lvgl/examples/libs/png/: img_wink_png.c lv_example_png_1.c
    ../lvgl/examples/libs/qrcode/: lv_example_qrcode_1.c
    ../lvgl/examples/libs/rlottie/: lv_example_rlottie_1.c lv_example_rlottie_2.c lv_example_rlottie_approve.c
    ../lvgl/examples/libs/sjpg/: lv_example_sjpg_1.c
    ../lvgl/examples/others/fragment/: lv_example_fragment_1.c lv_example_fragment_2.c
    ../lvgl/examples/others/gridnav/: lv_example_gridnav_1.c lv_example_gridnav_2.c lv_example_gridnav_3.c lv_example_gridnav_4.c
    ../lvgl/examples/others/ime/: lv_example_ime_pinyin_1.c lv_example_ime_pinyin_2.c
    ../lvgl/examples/others/imgfont/: lv_example_imgfont_1.c
    ../lvgl/examples/others/monkey/: lv_example_monkey_1.c lv_example_monkey_2.c lv_example_monkey_3.c
    ../lvgl/examples/others/msg/: lv_example_msg_1.c lv_example_msg_2.c lv_example_msg_3.c
    ../lvgl/examples/others/snapshot/: lv_example_snapshot_1.c
    ../lvgl/examples/widgets/animimg/: lv_example_animimg_1.c
    ../lvgl/examples/widgets/arc/: lv_example_arc_1.c lv_example_arc_2.c
    ../lvgl/examples/widgets/bar/: lv_example_bar_1.c lv_example_bar_2.c lv_example_bar_3.c lv_example_bar_4.c lv_example_bar_5.c lv_example_bar_6.c
    ../lvgl/examples/widgets/btn/: lv_example_btn_1.c lv_example_btn_2.c lv_example_btn_3.c
    ../lvgl/examples/widgets/btnmatrix/: lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c lv_example_btnmatrix_3.c
    ../lvgl/examples/widgets/calendar/: lv_example_calendar_1.c
    ../lvgl/examples/widgets/canvas/: lv_example_canvas_1.c lv_example_canvas_2.c
    ../lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c lv_example_chart_8.c lv_example_chart_9.c
    ../lvgl/examples/widgets/checkbox/: lv_example_checkbox_1.c lv_example_checkbox_2.c
    ../lvgl/examples/widgets/colorwheel/: lv_example_colorwheel_1.c
    ../lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
    ../lvgl/examples/widgets/img/: lv_example_img_1.c lv_example_img_2.c lv_example_img_3.c lv_example_img_4.c
    ../lvgl/examples/widgets/imgbtn/: lv_example_imgbtn_1.c
    ../lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c
    ../lvgl/examples/widgets/label/: lv_example_label_1.c lv_example_label_2.c lv_example_label_3.c lv_example_label_4.c lv_example_label_5.c
    ../lvgl/examples/widgets/led/: lv_example_led_1.c
    ../lvgl/examples/widgets/line/: lv_example_line_1.c
    ../lvgl/examples/widgets/list/: lv_example_list_1.c lv_example_list_2.c
    ../lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
    ../lvgl/examples/widgets/meter/: lv_example_meter_1.c lv_example_meter_2.c lv_example_meter_3.c lv_example_meter_4.c
    ../lvgl/examples/widgets/msgbox/: lv_example_msgbox_1.c
    ../lvgl/examples/widgets/obj/: lv_example_obj_1.c lv_example_obj_2.c
    ../lvgl/examples/widgets/roller/: lv_example_roller_1.c lv_example_roller_2.c lv_example_roller_3.c
    ../lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c
    ../lvgl/examples/widgets/span/: lv_example_span_1.c
    ../lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
    ../lvgl/examples/widgets/spinner/: lv_example_spinner_1.c
    ../lvgl/examples/widgets/switch/: lv_example_switch_1.c
    ../lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
    ../lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
    ../lvgl/examples/widgets/textarea/: lv_example_textarea_1.c lv_example_textarea_2.c lv_example_textarea_3.c
    ../lvgl/examples/widgets/tileview/: lv_example_tileview_1.c
    ../lvgl/examples/widgets/win/: lv_example_win_1.c
    ../lvgl/demos/benchmark/: lv_demo_benchmark.c
    ../lvgl/demos/keypad_encoder/: lv_demo_keypad_encoder.c
    ../lvgl/demos/music/: lv_demo_music.c lv_demo_music_list.c lv_demo_music_main.c
    ../lvgl/demos/stress/: lv_demo_stress.c
    ../lvgl/demos/widgets/: lv_demo_widgets.c
    ../lvgl/demos/benchmark/assets/: img_benchmark_cogwheel_alpha16.c img_benchmark_cogwheel_argb.c img_benchmark_cogwheel_chroma_keyed.c img_benchmark_cogwheel_indexed16.c img_benchmark_cogwheel_rgb.c img_benchmark_cogwheel_rgb565a8.c lv_font_bechmark_montserrat_12_compr_az.c.c lv_font_bechmark_montserrat_16_compr_az.c.c lv_font_bechmark_montserrat_28_compr_az.c.c
    ../lvgl/demos/music/assets/: img_lv_demo_music_btn_corner_large.c img_lv_demo_music_btn_list_pause.c img_lv_demo_music_btn_list_pause_large.c img_lv_demo_music_btn_list_play.c img_lv_demo_music_btn_list_play_large.c img_lv_demo_music_btn_loop.c img_lv_demo_music_btn_loop_large.c img_lv_demo_music_btn_next.c img_lv_demo_music_btn_next_large.c img_lv_demo_music_btn_pause.c img_lv_demo_music_btn_pause_large.c img_lv_demo_music_btn_play.c img_lv_demo_music_btn_play_large.c img_lv_demo_music_btn_prev.c img_lv_demo_music_btn_prev_large.c img_lv_demo_music_btn_rnd.c img_lv_demo_music_btn_rnd_large.c img_lv_demo_music_corner_left.c img_lv_demo_music_corner_left_large.c img_lv_demo_music_corner_right.c img_lv_demo_music_corner_right_large.c img_lv_demo_music_cover_1.c img_lv_demo_music_cover_1_large.c img_lv_demo_music_cover_2.c img_lv_demo_music_cover_2_large.c img_lv_demo_music_cover_3.c img_lv_demo_music_cover_3_large.c img_lv_demo_music_icon_1.c img_lv_demo_music_icon_1_large.c img_lv_demo_music_icon_2.c img_lv_demo_music_icon_2_large.c img_lv_demo_music_icon_3.c img_lv_demo_music_icon_3_large.c img_lv_demo_music_icon_4.c img_lv_demo_music_icon_4_large.c img_lv_demo_music_list_border.c img_lv_demo_music_list_border_large.c img_lv_demo_music_logo.c img_lv_demo_music_slider_knob.c img_lv_demo_music_slider_knob_large.c img_lv_demo_music_wave_bottom.c img_lv_demo_music_wave_bottom_large.c img_lv_demo_music_wave_top.c img_lv_demo_music_wave_top_large.c
    ../lvgl/demos/widgets/assets/: img_clothes.c img_demo_widgets_avatar.c img_lvgl_logo.c
