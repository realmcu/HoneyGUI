# Keil uVision project template.uvprojx, settings and files
target HoneyGUI (6220000::V6.22::.\ArmCompilerforEmbedded6.22)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: HoneyGUI (library)
  c flags: Optim=5 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c include: .;.;..\example\root_image;gui_port;..\app;..\dc;..\engine;..\input;..\misc;..\misc\tlsf;..\server;..\widget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fvp_sse300_mps3_s.sct
