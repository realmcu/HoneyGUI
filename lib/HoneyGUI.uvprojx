# Keil uVision project HoneyGUI.uvprojx, settings and files
target HoneyGUI (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HoneyGUI (library)
  AfterMake: header_copy.bat
  c flags: Optim=3 uC99=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: DRV_PIXEL_BITS=16 ENABLE_HONEYGUI DRV_LCD_HIGHT=480 DRV_LCD_WIDTH=480
  c misc: --fpu=FPv5-SP --gnu  --bss_threshold=0 --library_interface=aeabi_clib --no-multibyte-chars
  c include: .;.;..\realgui;..\realgui\3rd\cJSON;..\realgui\3rd\ezXML;..\realgui\3rd\nanosvg\src;..\realgui\3rd\nanovg;..\realgui\3rd\nanovg\agge;..\realgui\3rd\nanovg\base;..\realgui\3rd\nanovg\agge;..\realgui\3rd\nanovg\vglite;..\realgui\3rd\stb;..\realgui\3rd\tinyobj;..\realgui\3rd\tjpgd;..\realgui\3rd\minimp3;..\realgui\app;..\realgui\widget\3d;..\realgui\core;..\realgui\dc;..\realgui\DOM;..\realgui\engine;..\realgui\example\demo;..\realgui\input;..\realgui\misc;..\realgui\misc\tlsf;..\realgui\SaaA;..\realgui\server;..\realgui\widget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\fvp_sse300_mps3_s.sct
  group menuconfig
    ./: menu_config.h
  group realgui/3rd
    ../realgui/3rd/cJSON/: cJSON.c
    ../realgui/3rd/ezXML/: ezxml.c
    ../realgui/3rd/nanovg/base/: nanovg.c
    ../realgui/3rd/nanovg/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp nanovg_agge.cpp nanovg_vertex.cpp
    ../realgui/3rd/stb/: stb_image.cpp
    ../realgui/3rd/tjpgd/: tjpgd.c
  group realgui/app
    ../realgui/app/: gui_app.c
    ../realgui/widget/3d/: def_3d.c
  group realgui/dc
    ../realgui/dc/: gui_fb.c
  group realgui/dom
    ../realgui/DOM/: XML_DOM.c
  group realgui/engine
    ../realgui/engine/: draw_img.c gui_matrix.c draw_font.c font_mem.c font_mem_img.c font_mem_matrix.c font_stb.c acc_sw.c acc_sw_raster.c acc_init.c acc_sw_blend.c acc_sw_rle.c acc_sw_cover.c acc_sw_bypass.c acc_sw_filter.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
  group realgui/demo
    ../realgui/example/demo/: app_ui_realgui_base.c
  group realgui/input
    ../realgui/input/: kb_algo.c tp_algo.c tp_algo_v2.c wheel_algo.c
  group realgui/misc
    ../realgui/misc/tlsf/: tlsf.c
  group realgui/server
    ../realgui/server/: gui_api.c gui_components_init.c gui_message.c gui_pm.c gui_server.c
  group realgui/widget
    ../realgui/widget/: gui_3d.c gui_barcode_gen.c gui_button.c gui_calendar.c gui_canvas.c gui_canvas_arc.c gui_canvas_img.c gui_canvas_rect.c gui_canvas_round_rect.c gui_card.c gui_cardview.c gui_circle.c gui_colorwheel.c gui_combo.c gui_cube.c gui_curtain.c gui_curtainview.c gui_eq.c gui_fps.c gui_gallery.c gui_grid.c gui_image_array.c gui_img.c gui_img_live.c gui_img_scope.c gui_img_stb.c gui_keyboard.c gui_map.c gui_menu_cellular.c gui_multi_level.c gui_obj.c gui_page.c gui_pagelist.c gui_pagelist_new.c gui_pagelistview.c gui_perspective.c gui_pinyinIME.c gui_progressbar.c gui_qbcode.c gui_qrcode_gen.c gui_return.c gui_scroll_text.c gui_scroll_wheel_new.c gui_seekbar.c gui_simple_img.c gui_slider.c gui_soccer.c gui_svg.c gui_switch.c gui_tab.c gui_tab_cube.c gui_tab_fade.c gui_tab_reduction.c gui_tab_reduction_fade.c gui_tab_rotate.c gui_tabview.c gui_text.c gui_turn_table.c gui_watch_gradient_spot.c gui_watchface_gradient.c gui_wave.c gui_wheel_list.c gui_widget_template.c gui_win.c
