# Keil uVision project HoneyGUI.uvprojx, settings and files
target gui_sim (6220000::V6.22::..\..\AC\622)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.5.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x00000000,0x00080000) IROM(0x10000000,0x00200000) XRAM(0x01000000,0x00100000) XRAM2(0x20000000,0x00020000) XRAM3(0x20020000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: app
  c flags: Optim=2 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: DRV_LCD_WIDTH=480 DRV_PIXEL_BITS=16 ENABLE_HONEYGUI DRV_LCD_HEIGHT=480
  c include: .;.;..\..\..\realgui\example\root_image;gui_port;platform;..\..\..\realgui;..\..\..\realgui\3rd;..\..\..\realgui\3rd\cgltf;..\..\..\realgui\3rd\gifdec;..\..\..\realgui\3rd\h264bsd;..\..\..\realgui\3rd\h264bsd\inc;..\..\..\realgui\3rd\h264bsd\port;..\..\..\realgui\3rd\h264bsd\src;..\..\..\realgui\3rd\nanosvg;..\..\..\realgui\3rd\nanovg;..\..\..\realgui\3rd\nanovg\agge;..\..\..\realgui\3rd\nanovg\base;..\..\..\realgui\3rd\stb;..\..\..\realgui\3rd\tinyobj;..\..\..\realgui\3rd\tjpgd;..\..\..\realgui\core;..\..\..\realgui\dc;..\..\..\realgui\engine;..\..\..\realgui\engine\accel_hal;..\..\..\realgui\engine\blit;..\..\..\realgui\engine\blit\color;..\..\..\realgui\engine\codec;..\..\..\realgui\engine\codec\idu;..\..\..\realgui\engine\codec\jpeg;..\..\..\realgui\engine\blit\acc_sw_compressed;..\..\..\realgui\engine\draw;..\..\..\realgui\engine\font;..\..\..\realgui\engine\post_process;..\..\..\realgui\input;..\..\..\realgui\misc;..\..\..\realgui\misc\tlsf;..\..\..\realgui\misc\vfs;..\..\..\realgui\misc\vfs\romfs;..\..\..\realgui\server;..\..\..\realgui\widget;..\..\..\realgui\widget\gui_canvas;..\..\..\realgui\widget\gui_geometry;..\..\..\realgui\widget\gui_glass;..\..\..\realgui\widget\gui_gray;..\..\..\realgui\widget\gui_img;..\..\..\realgui\widget\gui_list;..\..\..\realgui\widget\gui_lottie;..\..\..\realgui\widget\gui_menu_cellular;..\..\..\realgui\widget\gui_obj;..\..\..\realgui\widget\gui_qbcode;..\..\..\realgui\widget\gui_soccer;..\..\..\realgui\widget\gui_svg;..\..\..\realgui\widget\gui_text;..\..\..\realgui\widget\gui_video;..\..\..\realgui\widget\gui_view;..\..\..\realgui\widget\gui_win;..\..\..\example\application\hml_designer;..\..\..\example\widget\glass_effect;..\..\..\example\widget\glass_effect\root_image;..\..\..\example\widget\image
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT6: RAM 0x1000000 size 0x100000
  memory RVCT7: RAM 0x20000000 size 0x20000
  memory RVCT8: RAM 0x20020000 size 0x20000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x80000
  scatter file: .\fvp_sse300_mps3_s.sct
  group application
    ./: main.c
  group gui_port
    gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_os.c
    platform/: GLCD_Fonts.c GLCD_V2M-MPS3_AN547.c Touch_V2M-MPS3.c platform.c
  group 3rd
    ../../../realgui/3rd/gifdec/: gifdec.c
    ../../../realgui/3rd/h264bsd/port/: h264bsd_port.c
    ../../../realgui/3rd/h264bsd/src/: YUV2RGB.c gui_h264bsd.c h264bsdTest.c h264bsd_byte_stream.c h264bsd_cavlc.c h264bsd_conceal.c h264bsd_deblocking.c h264bsd_decoder.c h264bsd_dpb.c h264bsd_image.c h264bsd_inter_prediction.c h264bsd_intra_prediction.c h264bsd_macroblock_layer.c h264bsd_nal_unit.c h264bsd_neighbour.c h264bsd_pic_order_cnt.c h264bsd_pic_param_set.c h264bsd_reconstruct.c h264bsd_sei.c h264bsd_seq_param_set.c h264bsd_slice_data.c h264bsd_slice_group_map.c h264bsd_slice_header.c h264bsd_storage.c h264bsd_stream.c h264bsd_transform.c h264bsd_util.c h264bsd_vlc.c h264bsd_vui.c
    ../../../realgui/3rd/nanovg/agge/: math.cpp nanovg_agge.cpp nanovg_vertex.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../../../realgui/3rd/nanovg/base/: nanovg.c nanovg_port.c
    ../../../realgui/3rd/stb/: stb_image.cpp
    ../../../realgui/3rd/tjpgd/: tjpgd.c
  group core
    ../../../realgui/core/: gui_math.c gui_matrix.c
  group dc
    ../../../realgui/dc/: gui_fb.c
  group engine
    ../../../realgui/engine/accel_hal/: acc_api.c
    ../../../realgui/engine/blit/: acc_sw_uncompressed.c acc_sw_entry.c acc_sw_arm2d_blur.c acc_sw_generic.c
    ../../../realgui/engine/blit/color/: a8_2_a8.c a8_2_rgb565.c argb8565_2_rgb565.c rgb565_2_rgb565.c
    ../../../realgui/engine/codec/idu/: acc_sw_idu.c
    ../../../realgui/engine/codec/jpeg/: acc_sw_jpeg.c
    ../../../realgui/engine/blit/acc_sw_compressed/: acc_sw_compressed.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
    ../../../realgui/engine/draw/: draw_font.c draw_img.c
    ../../../realgui/engine/font/: font_custom.c font_lib_manager.c font_mem.c font_mem_img.c font_mem_matrix.c font_rendering_utils.c font_stb.c font_ttf.c
    ../../../realgui/engine/post_process/: gui_post_process.c
  group input
    ../../../realgui/input/: kb_algo.c tp_algo.c wheel_algo.c
  group misc
    ../../../realgui/misc/tlsf/: tlsf.c
    ../../../realgui/misc/vfs/: gui_vfs.c gui_vfs_generic.c gui_vfs_posix.c gui_vfs_ramfs.c gui_vfs_romfs.c
    ../../../realgui/misc/vfs/romfs/: hg_romfs.c
  group server
    ../../../realgui/server/: gui_api_acc.c gui_api_audio.c gui_api_color.c gui_api_dc.c gui_api_ftl.c gui_api_indev.c gui_api_os.c gui_components_init.c gui_listener.c gui_message.c gui_pm.c gui_server.c
  group widget
    ../../../realgui/widget/gui_canvas/: gui_canvas.c gui_canvas_img.c
    ../../../realgui/widget/gui_geometry/: gui_arc.c gui_arc_group.c gui_circle.c gui_rect.c lite_geometry.c lite_geometry_math.c
    ../../../realgui/widget/gui_glass/: gui_glass.c
    ../../../realgui/widget/gui_img/: gui_img.c gui_img_api.c
    ../../../realgui/widget/gui_list/: gui_list.c gui_list_rotate_curl.c gui_list_rotate_helix.c
    ../../../realgui/widget/gui_lottie/: gui_lottie.c
    ../../../realgui/widget/gui_menu_cellular/: gui_menu_cellular.c
    ../../../realgui/widget/gui_obj/: gui_obj.c gui_obj_event.c gui_obj_suppress.c gui_obj_timer.c gui_obj_tree.c
    ../../../realgui/widget/gui_qbcode/: gui_barcode_gen.c gui_qbcode.c gui_qrcode_gen.c
    ../../../realgui/widget/gui_soccer/: gui_soccer.c
    ../../../realgui/widget/gui_svg/: gui_svg.c
    ../../../realgui/widget/gui_text/: gui_scroll_text.c gui_text.c
    ../../../realgui/widget/gui_video/: gui_video.c
    ../../../realgui/widget/gui_view/: gui_view.c gui_view_animate.c gui_view_blur.c gui_view_cube.c gui_view_descriptor.c gui_view_reduction.c gui_view_rotate.c gui_view_translation.c
    ../../../realgui/widget/gui_win/: gui_win.c
  group realgui/demo
    ../../../example/widget/image/: example_img.c
software components: CMSIS:CORE 6.1.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Device:Startup 2.0.0, Utilities:perf_counter:Core 2.3.1, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0
