# Keil uVision project gui_engine.uvprojx, settings and files
target gui_sim (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app
  c flags: Optim=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: GUI_KEIL_SIM
  c misc: --diag_suppress=1
  c include: .;.;..\example\root_image;gui_port;..\app;..\dc;..\engine;..\input;..\misc;..\misc\tlsf;..\server;..\Third_Party;..\Third_Party\nanosvg\src;..\Third_Party\nanosvg\example;..\Third_Party\agge\agge;..\Third_Party\nanovg\base;..\Third_Party\nanovg\agge;..\Third_Party\agge;..\Third_Party\nanovg;..\widget;..\example;..\example\root_image
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  group application
    ./: main.c rtk_gui_demo.c
  group rtk_gui
    gui_port/: gui_port_dc.c gui_port_filesystem.c gui_port_os.c
    ../app/: gui_app.c
    ../dc/: gui_fb.c
    ../engine/: draw_img.c gui_matrix.c draw_font.c font_mem.c image_bitmap.c font_stb.c acc_sw.c acc_init.c
    ../input/: gui_kb.c tp_algo.c
    ../misc/tlsf/: tlsf.c
    ../server/: gui_api.c gui_server.c
    ../Third_Party/agge/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp
    ../Third_Party/nanovg/demos/: agge_fill.c
    ../Third_Party/nanovg/base/: nanovg.c
    ../Third_Party/nanovg/agge/: nanovg_agge.cpp nanovg_vertex.cpp
    ../widget/: gui_alert.c gui_arc.c gui_arc_hl.c gui_bitmap.c gui_button.c gui_canvas.c gui_chart_bars.c gui_circle.c gui_cube.c gui_curtain.c gui_curtainview.c gui_d_island.c gui_dynamic_img.c gui_graphic.c gui_grid.c gui_icon.c gui_icon_default.c gui_iconlist.c gui_iconlist_default.c gui_img.c gui_img_with_animate.c gui_magic_img.c gui_obj.c gui_page.c gui_path.c gui_progressbar.c gui_rectangle.c gui_ring.c gui_round_corner_rect.c gui_round_rect.c gui_scroll_text.c gui_scroll_wheel.c gui_seekbar.c gui_stb_img.c gui_tabview.c gui_text.c gui_win.c gui_window_border.c
  group gui_demo
    ../example/: app_launcher2.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.1, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Board Support:Common 2.0.0, Board Support:Graphic LCD 2.0.0, Device:Startup 1.1.0
