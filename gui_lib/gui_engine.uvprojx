# Keil uVision project gui_engine.uvprojx, settings and files
target gui_lib (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: gui_lib (library)
  c flags: Optim=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: ENABLE_RTK_GUI_FONT_RTK_MEM TARGET_RTL8773E ENABLE_RTK_GUI_FONT_STB ENABLE_RTK_GUI
  c misc: --diag_suppress=1
  c include: .;.;..\gui_engine;..\gui_engine\3rd\ezXML;..\gui_engine\3rd\nanosvg\src;..\gui_engine\3rd\nanovg;..\gui_engine\3rd\nanovg\agge;..\gui_engine\3rd\nanovg\base;..\gui_engine\3rd\nanovg\agge;..\gui_engine\3rd\nanovg\vglite;..\gui_engine\3rd\stb;..\gui_engine\3rd\tjpgd;..\gui_engine\app;..\gui_engine\dc;..\gui_engine\engine;..\gui_engine\input;..\gui_engine\misc;..\gui_engine\misc\tlsf;..\gui_engine\SaaA;..\gui_engine\server;..\gui_engine\widget
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\mps2.sct
  group menuconfig
    ./: menu_config.h
  group realgui/3rd
    ../gui_engine/3rd/nanovg/base/: nanovg.c
    ../gui_engine/3rd/nanovg/agge/: math.cpp stroke.cpp stroke_features.cpp vector_rasterizer.cpp nanovg_agge.cpp nanovg_vertex.cpp
    ../gui_engine/3rd/tjpgd/: tjpgd.c
  group realgui/app
    ../gui_engine/app/: gui_app.c
  group realgui/dc
    ../gui_engine/dc/: gui_fb.c
  group realgui/engine
    ../gui_engine/engine/: draw_img.c gui_matrix.c draw_font.c font_mem.c font_stb.c acc_sw.c acc_sw_raster.c acc_init.c acc_sw_blend.c acc_sw_rle.c acc_sw_cover.c acc_sw_bypass.c acc_sw_filter.c acc_sw_rle_bypass.c acc_sw_rle_cover.c acc_sw_rle_filter.c
  group realgui/input
    ../gui_engine/input/: kb_algo.c tp_algo.c tp_algo_v2.c wheel_algo.c
  group realgui/misc
    ../gui_engine/misc/tlsf/: tlsf.c
  group realgui/server
    ../gui_engine/server/: gui_api.c gui_components_init.c gui_server.c
  group realgui/widget
    ../gui_engine/widget/: gui_barcode_gen.c gui_button.c gui_canvas.c gui_canvas_rect.c gui_card.c gui_cardview.c gui_colorwheel.c gui_cube.c gui_curtain.c gui_curtainview.c gui_eq.c gui_fps.c gui_grid.c gui_img.c gui_img_scope.c gui_img_stb.c gui_map.c gui_menu_cellular.c gui_obj.c gui_page.c gui_pagelist.c gui_pagelistview.c gui_perspective.c gui_progressbar.c gui_qbcode.c gui_qrcode_gen.c gui_rect.c gui_return.c gui_scroll_text.c gui_seekbar.c gui_simple_img.c gui_svg.c gui_switch.c gui_tab.c gui_tab_cube.c gui_tab_fade.c gui_tab_reduction.c gui_tab_reduction_fade.c gui_tab_rotate.c gui_tabview.c gui_text.c gui_watch_gradient_spot.c gui_watchface_gradient.c gui_wave.c gui_wheel_list.c gui_widget_template.c gui_win.c
